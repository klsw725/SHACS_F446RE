<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SHACS_F446RE.ewp</path>
  </project>
  <batchBuild />
</workspace>
