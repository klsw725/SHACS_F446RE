# IAR project SHACS_F446RE.ewp, settings and files
configuration SHACS_F446RE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\Third_Party\BTSerialApp; ..\Middlewares\Third_Party\USBSerialApp; ..\Middlewares\Third_Party\WifiSerialApp; ..\Middlewares\Third_Party\ZWHostApp; ..\Middlewares\Third_Party\ZWSerialAPI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: SHACS_F446RE.hex
  ILINK.IlinkOutputFile: SHACS_F446RE.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Middlewares/BTSerialApp
    ../Middlewares/Third_Party/BTSerialApp/: BtSerial.h BtSerialAPI.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USBSerialApp
    ../Middlewares/Third_Party/USBSerialApp/: UsbSerial.h UsbSerialAPI.c
  group Middlewares/WifiSerialApp
    ../Middlewares/Third_Party/WifiSerialApp/: WifiSerial.h WifiSerialAPI.c
  group Middlewares/ZWHostApp
    ../Middlewares/Third_Party/ZWHostApp/: networkManagement.cpp networkManagement.h timing.cpp timing.h ZWhostApp.cpp ZWhostApp.h
  group Middlewares/ZWSerialAPI
    ../Middlewares/Third_Party/ZWSerialAPI/: ZW_classcmd.h ZW_SerialAPI.h ZwSerial.cpp ZwSerial.h ZwSerialAPI.cpp ZwSerialAPI.h
